## drivers/misc/test_module/Kconfig
```kconfig
config TEST_MODULE
	tristate 'Randomization Test Module'
	default m
	help
		Code to test fine grained KASLR
```
